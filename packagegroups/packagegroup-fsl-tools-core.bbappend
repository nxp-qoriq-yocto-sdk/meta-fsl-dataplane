RDEPENDS_${PN}_append_ls1043ardb = " odp"
RDEPENDS_${PN}_append_ls2080ardb = " odp"
RDEPENDS_${PN}_append_t1040d4rdb-64b = " odp"
RDEPENDS_${PN}_append_t4240rdb-64b = " odp"
